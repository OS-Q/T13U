# Keil uVision project Project.uvproj, settings and files
target CH552 (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\
  link misc: REMOVEUNUSED
  group User
    ../src/: Debug.C Main.C
